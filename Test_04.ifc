Properties of the parts of a building model (IFC4), part 1 of 2

# File
Description: ViewDefinition [ReferenceView]
File name: Test_04.ifc
Time: 2025-06-24T13:36:40+02:00
Written by: IfcOpenShell 0.8.2
Made in: Bonsai 0.8.2

# IfcProject, 2024047 - WSS - Bauteilgarten UB
Description: Bauteilgarten UB
ModelAuthorAndLicenseData - Author: Oliver Jung; AuthorEmail: o.jung@wernerconsult.com

# IfcBuilding
ElevationOfRefHeight: 0 m

# IfcBuildingStorey (5)
Elevation: 0 m
Name
Oberbauschotter-Gleis-1
Oberbauschotter-Gleis-2
Schiene
Schwelle
Referenzpunkt

# IfcBuildingElementProxy (480)
OEBBset_Referenzen - Anlagenkuerzel: ND; Anlagenreferenznummer: ND; AVS-ID: ND; Anlagennummer_SAP_ID: ND; GewerkARS: ND; ReferenzIDIMMOAssi: ND
OEBBset_Links - Dokumenten_Uebergabeprotokoll: ND; Bestandsunterlage: ND; Komponentendokumentation: ND; Produktdatenblatt: ND; Gewaehrleistung: ND; Eintrag_IH_System: ND; Anlagenfoto: ND; Eintrag_AVS: https:\\avs.oebb.at
OEBBset_Semantik_Topologie - 20_Topologie_Ebene_1: Strecke; 29_Topologie_Ebene_5_Bezeichnung: ND; 33_Elementbezeichnung: ND; 51_PUID: ND; 28_Topologie_Ebene_5: ND; 10_Streckennummer: ND; 11_Projektnummer: ND; 12_TeilProjekt: ND; 21_Topologie_Ebene_1_Bezeichnung: ND; 23_Topologie_Ebene_2_Bezeichnung: ND; 25_Topologie_Ebene_3_Bezeichnung: ND; 26_Topologie_Ebene_4: ND; 27_Topologie_Ebene_4_Bezeichnung: ND; 30_Kategorie: ND; 31_Elementklasse: ND; 13_GewerkBIM: Oberbau; 22_Topologie_Ebene_2: Abschnitt; 40_Referenzachse: Gleis 1; 50_Investitionsart: PUI
ProVI - PVI_STATIONSBEZUG_001P: Achse 001P (RQ 2 gleisig SFE Querung Gleis 1); PVI_STATIONSBEZUG: Achse 001P (RQ 2 gleisig SFE Querung Gleis 1); PVI_BEZEICHNUNG_PROJEKT: 2024047 - WSS - Bauteilgarten UB; PVI_NUMMER_PROJEKT: -; PVI_BEZEICHNUNG_DATEI: RQ 2 gleisig SFE Querung Gleis 1
Name | In | 42_kmEnde = PVI_KM_BIS_001P = PVI_KM_BIS | 24_Topologie_Ebene_3 | 41_kmAnfang = PVI_KM_VON = PVI_KM_VON_001P | 32_Element | PVI_BAUTEILGRUPPE | PVI_STAT_BIS = PVI_STAT_BIS_001P | PVI_STAT_VON = PVI_STAT_VON_001P | PVI_BAUTEILTYP | PVI_ELEMENT_HOEHE | PVI_TYP | PVI_BEZEICHNUNG_GLEIS | PVI_ELEMENT_LAENGE | PVI_ELEMENT_BREITE
Oberbauschotter-Gleis-1 | Oberbauschotter-Gleis-1 | 0,780.000 | Gleis 1 | 0,779.500 | Oberbauschotter | Erdbau | 780 | 779.5 | Oberbauschotter-Gleis-1 | OEBBset_Semantik_Topologie - 34_Elementtyp: ND; 35_Instandhaltungsbezeichnung: ND; OEBBset_Schotterbett - MinSchotterbettbreite: 3,60; MinSchotterbettstaerke: 0,50; Koernung: Klasse 1; IstGewaschen: Ja; ProVI - PVI_VOLUMEN_REB_M3: 1.102; PVI_VOLUMEN_M3: 1.102; PVI_SCHICHTSTAERKE: 0; PVI_FLAECHE_M2: 2.007
Oberbauschotter-Gleis-1 | Oberbauschotter-Gleis-1 | 0,790.000 | Gleis 1 | 0,780.000 | Oberbauschotter | Erdbau | 790 | 780 | Oberbauschotter-Gleis-1 | OEBBset_Semantik_Topologie - 34_Elementtyp: ND; 35_Instandhaltungsbezeichnung: ND; OEBBset_Schotterbett - MinSchotterbettbreite: 3,60; MinSchotterbettstaerke: 0,50; Koernung: Klasse 1; IstGewaschen: Ja; ProVI - PVI_VOLUMEN_REB_M3: 22.034; PVI_VOLUMEN_M3: 22.034; PVI_SCHICHTSTAERKE: 0; PVI_FLAECHE_M2: 40.15
Oberbauschotter-Gleis-1 | Oberbauschotter-Gleis-1 | 0,800.000 | Gleis 1 | 0,790.000 | Oberbauschotter | Erdbau | 800 | 790 | Oberbauschotter-Gleis-1 | OEBBset_Semantik_Topologie - 34_Elementtyp: ND; 35_Instandhaltungsbezeichnung: ND; OEBBset_Schotterbett - MinSchotterbettbreite: 3,60; MinSchotterbettstaerke: 0,50; Koernung: Klasse 1; IstGewaschen: Ja; ProVI - PVI_VOLUMEN_REB_M3: 22.034; PVI_VOLUMEN_M3: 22.034; PVI_SCHICHTSTAERKE: 0; PVI_FLAECHE_M2: 40.15
Oberbauschotter-Gleis-1 | Oberbauschotter-Gleis-1 | 0,810.000 | Gleis 1 | 0,800.000 | Oberbauschotter | Erdbau | 810 | 800 | Oberbauschotter-Gleis-1 | OEBBset_Semantik_Topologie - 34_Elementtyp: ND; 35_Instandhaltungsbezeichnung: ND; OEBBset_Schotterbett - MinSchotterbettbreite: 3,60; MinSchotterbettstaerke: 0,50; Koernung: Klasse 1; IstGewaschen: Ja; ProVI - PVI_VOLUMEN_REB_M3: 22.034; PVI_VOLUMEN_M3: 22.034; PVI_SCHICHTSTAERKE: 0; PVI_FLAECHE_M2: 40.15
Oberbauschotter-Gleis-1 | Oberbauschotter-Gleis-1 | 0,820.000 | Gleis 1 | 0,810.000 | Oberbauschotter | Erdbau | 820 | 810 | Oberbauschotter-Gleis-1 | OEBBset_Semantik_Topologie - 34_Elementtyp: ND; 35_Instandhaltungsbezeichnung: ND; OEBBset_Schotterbett - MinSchotterbettbreite: 3,60; MinSchotterbettstaerke: 0,50; Koernung: Klasse 1; IstGewaschen: Ja; ProVI - PVI_VOLUMEN_REB_M3: 22.034; PVI_VOLUMEN_M3: 22.034; PVI_SCHICHTSTAERKE: 0; PVI_FLAECHE_M2: 40.15
Oberbauschotter-Gleis-1 | Oberbauschotter-Gleis-1 | 0,830.000 | Gleis 1 | 0,820.000 | Oberbauschotter | Erdbau | 830 | 820 | Oberbauschotter-Gleis-1 | OEBBset_Semantik_Topologie - 34_Elementtyp: ND; 35_Instandhaltungsbezeichnung: ND; OEBBset_Schotterbett - MinSchotterbettbreite: 3,60; MinSchotterbettstaerke: 0,50; Koernung: Klasse 1; IstGewaschen: Ja; ProVI - PVI_VOLUMEN_REB_M3: 22.034; PVI_VOLUMEN_M3: 22.034; PVI_SCHICHTSTAERKE: 0; PVI_FLAECHE_M2: 40.15
Oberbauschotter-Gleis-1 | Oberbauschotter-Gleis-1 | 0,840.000 | Gleis 1 | 0,830.000 | Oberbauschotter | Erdbau | 840 | 830 | Oberbauschotter-Gleis-1 | OEBBset_Semantik_Topologie - 34_Elementtyp: ND; 35_Instandhaltungsbezeichnung: ND; OEBBset_Schotterbett - MinSchotterbettbreite: 3,60; MinSchotterbettstaerke: 0,50; Koernung: Klasse 1; IstGewaschen: Ja; ProVI - PVI_VOLUMEN_REB_M3: 22.034; PVI_VOLUMEN_M3: 22.034; PVI_SCHICHTSTAERKE: 0; PVI_FLAECHE_M2: 40.15
Oberbauschotter-Gleis-1 | Oberbauschotter-Gleis-1 | 0,850.000 | Gleis 1 | 0,840.000 | Oberbauschotter | Erdbau | 850 | 840 | Oberbauschotter-Gleis-1 | OEBBset_Semantik_Topologie - 34_Elementtyp: ND; 35_Instandhaltungsbezeichnung: ND; OEBBset_Schotterbett - MinSchotterbettbreite: 3,60; MinSchotterbettstaerke: 0,50; Koernung: Klasse 1; IstGewaschen: Ja; ProVI - PVI_VOLUMEN_REB_M3: 22.034; PVI_VOLUMEN_M3: 22.034; PVI_SCHICHTSTAERKE: 0; PVI_FLAECHE_M2: 40.15
Oberbauschotter-Gleis-1 | Oberbauschotter-Gleis-1 | 0,860.000 | Gleis 1 | 0,850.000 | Oberbauschotter | Erdbau | 860 | 850 | Oberbauschotter-Gleis-1 | OEBBset_Semantik_Topologie - 34_Elementtyp: ND; 35_Instandhaltungsbezeichnung: ND; OEBBset_Schotterbett - MinSchotterbettbreite: 3,60; MinSchotterbettstaerke: 0,50; Koernung: Klasse 1; IstGewaschen: Ja; ProVI - PVI_VOLUMEN_REB_M3: 22.034; PVI_VOLUMEN_M3: 22.034; PVI_SCHICHTSTAERKE: 0; PVI_FLAECHE_M2: 40.15
Oberbauschotter-Gleis-1 | Oberbauschotter-Gleis-1 | 0,870.000 | Gleis 1 | 0,860.000 | Oberbauschotter | Erdbau | 870 | 860 | Oberbauschotter-Gleis-1 | OEBBset_Semantik_Topologie - 34_Elementtyp: ND; 35_Instandhaltungsbezeichnung: ND; OEBBset_Schotterbett - MinSchotterbettbreite: 3,60; MinSchotterbettstaerke: 0,50; Koernung: Klasse 1; IstGewaschen: Ja; ProVI - PVI_VOLUMEN_REB_M3: 22.034; PVI_VOLUMEN_M3: 22.034; PVI_SCHICHTSTAERKE: 0; PVI_FLAECHE_M2: 40.15
Oberbauschotter-Gleis-1 | Oberbauschotter-Gleis-1 | 0,880.000 | Gleis 1 | 0,870.000 | Oberbauschotter | Erdbau | 880 | 870 | Oberbauschotter-Gleis-1 | OEBBset_Semantik_Topologie - 34_Elementtyp: ND; 35_Instandhaltungsbezeichnung: ND; OEBBset_Schotterbett - MinSchotterbettbreite: 3,60; MinSchotterbettstaerke: 0,50; Koernung: Klasse 1; IstGewaschen: Ja; ProVI - PVI_VOLUMEN_REB_M3: 22.034; PVI_VOLUMEN_M3: 22.034; PVI_SCHICHTSTAERKE: 0; PVI_FLAECHE_M2: 40.15
Oberbauschotter-Gleis-1 | Oberbauschotter-Gleis-1 | 0,890.000 | Gleis 1 | 0,880.000 | Oberbauschotter | Erdbau | 890 | 880 | Oberbauschotter-Gleis-1 | OEBBset_Semantik_Topologie - 34_Elementtyp: ND; 35_Instandhaltungsbezeichnung: ND; OEBBset_Schotterbett - MinSchotterbettbreite: 3,60; MinSchotterbettstaerke: 0,50; Koernung: Klasse 1; IstGewaschen: Ja; ProVI - PVI_VOLUMEN_REB_M3: 22.034; PVI_VOLUMEN_M3: 22.034; PVI_SCHICHTSTAERKE: 0; PVI_FLAECHE_M2: 40.15
Oberbauschotter-Gleis-1 | Oberbauschotter-Gleis-1 | 0,900.000 | Gleis 1 | 0,890.000 | Oberbauschotter | Erdbau | 900 | 890 | Oberbauschotter-Gleis-1 | OEBBset_Semantik_Topologie - 34_Elementtyp: ND; 35_Instandhaltungsbezeichnung: ND; OEBBset_Schotterbett - MinSchotterbettbreite: 3,60; MinSchotterbettstaerke: 0,50; Koernung: Klasse 1; IstGewaschen: Ja; ProVI - PVI_VOLUMEN_REB_M3: 22.034; PVI_VOLUMEN_M3: 22.034; PVI_SCHICHTSTAERKE: 0; PVI_FLAECHE_M2: 40.15
Oberbauschotter-Gleis-2 | Oberbauschotter-Gleis-2 | 0,780.000 | Gleis 2 | 0,779.500 | Oberbauschotter | Erdbau | 780 | 779.5 | Oberbauschotter-Gleis-2 | OEBBset_Semantik_Topologie - 34_Elementtyp: ND; 35_Instandhaltungsbezeichnung: ND; OEBBset_Schotterbett - MinSchotterbettbreite: 3,60; MinSchotterbettstaerke: 0,50; Koernung: Klasse 1; IstGewaschen: Ja; ProVI - PVI_VOLUMEN_REB_M3: 1.459; PVI_VOLUMEN_M3: 1.459; PVI_SCHICHTSTAERKE: 0; PVI_FLAECHE_M2: 2.845
Oberbauschotter-Gleis-2 | Oberbauschotter-Gleis-2 | 0,790.000 | Gleis 2 | 0,780.000 | Oberbauschotter | Erdbau | 790 | 780 | Oberbauschotter-Gleis-2 | OEBBset_Semantik_Topologie - 34_Elementtyp: ND; 35_Instandhaltungsbezeichnung: ND; OEBBset_Schotterbett - MinSchotterbettbreite: 3,60; MinSchotterbettstaerke: 0,50; Koernung: Klasse 1; IstGewaschen: Ja; ProVI - PVI_VOLUMEN_REB_M3: 29.19; PVI_VOLUMEN_M3: 29.19; PVI_SCHICHTSTAERKE: 0; PVI_FLAECHE_M2: 56.907
Oberbauschotter-Gleis-2 | Oberbauschotter-Gleis-2 | 0,800.000 | Gleis 2 | 0,790.000 | Oberbauschotter | Erdbau | 800 | 790 | Oberbauschotter-Gleis-2 | OEBBset_Semantik_Topologie - 34_Elementtyp: ND; 35_Instandhaltungsbezeichnung: ND; OEBBset_Schotterbett - MinSchotterbettbreite: 3,60; MinSchotterbettstaerke: 0,50; Koernung: Klasse 1; IstGewaschen: Ja; ProVI - PVI_VOLUMEN_REB_M3: 29.19; PVI_VOLUMEN_M3: 29.19; PVI_SCHICHTSTAERKE: 0; PVI_FLAECHE_M2: 56.907
Oberbauschotter-Gleis-2 | Oberbauschotter-Gleis-2 | 0,810.000 | Gleis 2 | 0,800.000 | Oberbauschotter | Erdbau | 810 | 800 | Oberbauschotter-Gleis-2 | OEBBset_Semantik_Topologie - 34_Elementtyp: ND; 35_Instandhaltungsbezeichnung: ND; OEBBset_Schotterbett - MinSchotterbettbreite: 3,60; MinSchotterbettstaerke: 0,50; Koernung: Klasse 1; IstGewaschen: Ja; ProVI - PVI_VOLUMEN_REB_M3: 29.19; PVI_VOLUMEN_M3: 29.19; PVI_SCHICHTSTAERKE: 0; PVI_FLAECHE_M2: 56.907
Oberbauschotter-Gleis-2 | Oberbauschotter-Gleis-2 | 0,820.000 | Gleis 2 | 0,810.000 | Oberbauschotter | Erdbau | 820 | 810 | Oberbauschotter-Gleis-2 | OEBBset_Semantik_Topologie - 34_Elementtyp: ND; 35_Instandhaltungsbezeichnung: ND; OEBBset_Schotterbett - MinSchotterbettbreite: 3,60; MinSchotterbettstaerke: 0,50; Koernung: Klasse 1; IstGewaschen: Ja; ProVI - PVI_VOLUMEN_REB_M3: 29.19; PVI_VOLUMEN_M3: 29.19; PVI_SCHICHTSTAERKE: 0; PVI_FLAECHE_M2: 56.907
Oberbauschotter-Gleis-2 | Oberbauschotter-Gleis-2 | 0,830.000 | Gleis 2 | 0,820.000 | Oberbauschotter | Erdbau | 830 | 820 | Oberbauschotter-Gleis-2 | OEBBset_Semantik_Topologie - 34_Elementtyp: ND; 35_Instandhaltungsbezeichnung: ND; OEBBset_Schotterbett - MinSchotterbettbreite: 3,60; MinSchotterbettstaerke: 0,50; Koernung: Klasse 1; IstGewaschen: Ja; ProVI - PVI_VOLUMEN_REB_M3: 29.19; PVI_VOLUMEN_M3: 29.19; PVI_SCHICHTSTAERKE: 0; PVI_FLAECHE_M2: 56.907
Oberbauschotter-Gleis-2 | Oberbauschotter-Gleis-2 | 0,840.000 | Gleis 2 | 0,830.000 | Oberbauschotter | Erdbau | 840 | 830 | Oberbauschotter-Gleis-2 | OEBBset_Semantik_Topologie - 34_Elementtyp: ND; 35_Instandhaltungsbezeichnung: ND; OEBBset_Schotterbett - MinSchotterbettbreite: 3,60; MinSchotterbettstaerke: 0,50; Koernung: Klasse 1; IstGewaschen: Ja; ProVI - PVI_VOLUMEN_REB_M3: 29.19; PVI_VOLUMEN_M3: 29.19; PVI_SCHICHTSTAERKE: 0; PVI_FLAECHE_M2: 56.907
Oberbauschotter-Gleis-2 | Oberbauschotter-Gleis-2 | 0,850.000 | Gleis 2 | 0,840.000 | Oberbauschotter | Erdbau | 850 | 840 | Oberbauschotter-Gleis-2 | OEBBset_Semantik_Topologie - 34_Elementtyp: ND; 35_Instandhaltungsbezeichnung: ND; OEBBset_Schotterbett - MinSchotterbettbreite: 3,60; MinSchotterbettstaerke: 0,50; Koernung: Klasse 1; IstGewaschen: Ja; ProVI - PVI_VOLUMEN_REB_M3: 29.19; PVI_VOLUMEN_M3: 29.19; PVI_SCHICHTSTAERKE: 0; PVI_FLAECHE_M2: 56.907
Oberbauschotter-Gleis-2 | Oberbauschotter-Gleis-2 | 0,860.000 | Gleis 2 | 0,850.000 | Oberbauschotter | Erdbau | 860 | 850 | Oberbauschotter-Gleis-2 | OEBBset_Semantik_Topologie - 34_Elementtyp: ND; 35_Instandhaltungsbezeichnung: ND; OEBBset_Schotterbett - MinSchotterbettbreite: 3,60; MinSchotterbettstaerke: 0,50; Koernung: Klasse 1; IstGewaschen: Ja; ProVI - PVI_VOLUMEN_REB_M3: 29.19; PVI_VOLUMEN_M3: 29.19; PVI_SCHICHTSTAERKE: 0; PVI_FLAECHE_M2: 56.907
Oberbauschotter-Gleis-2 | Oberbauschotter-Gleis-2 | 0,870.000 | Gleis 2 | 0,860.000 | Oberbauschotter | Erdbau | 870 | 860 | Oberbauschotter-Gleis-2 | OEBBset_Semantik_Topologie - 34_Elementtyp: ND; 35_Instandhaltungsbezeichnung: ND; OEBBset_Schotterbett - MinSchotterbettbreite: 3,60; MinSchotterbettstaerke: 0,50; Koernung: Klasse 1; IstGewaschen: Ja; ProVI - PVI_VOLUMEN_REB_M3: 29.19; PVI_VOLUMEN_M3: 29.19; PVI_SCHICHTSTAERKE: 0; PVI_FLAECHE_M2: 56.907
Oberbauschotter-Gleis-2 | Oberbauschotter-Gleis-2 | 0,880.000 | Gleis 2 | 0,870.000 | Oberbauschotter | Erdbau | 880 | 870 | Oberbauschotter-Gleis-2 | OEBBset_Semantik_Topologie - 34_Elementtyp: ND; 35_Instandhaltungsbezeichnung: ND; OEBBset_Schotterbett - MinSchotterbettbreite: 3,60; MinSchotterbettstaerke: 0,50; Koernung: Klasse 1; IstGewaschen: Ja; ProVI - PVI_VOLUMEN_REB_M3: 29.19; PVI_VOLUMEN_M3: 29.19; PVI_SCHICHTSTAERKE: 0; PVI_FLAECHE_M2: 56.907
Oberbauschotter-Gleis-2 | Oberbauschotter-Gleis-2 | 0,890.000 | Gleis 2 | 0,880.000 | Oberbauschotter | Erdbau | 890 | 880 | Oberbauschotter-Gleis-2 | OEBBset_Semantik_Topologie - 34_Elementtyp: ND; 35_Instandhaltungsbezeichnung: ND; OEBBset_Schotterbett - MinSchotterbettbreite: 3,60; MinSchotterbettstaerke: 0,50; Koernung: Klasse 1; IstGewaschen: Ja; ProVI - PVI_VOLUMEN_REB_M3: 29.19; PVI_VOLUMEN_M3: 29.19; PVI_SCHICHTSTAERKE: 0; PVI_FLAECHE_M2: 56.907
Oberbauschotter-Gleis-2 | Oberbauschotter-Gleis-2 | 0,900.000 | Gleis 2 | 0,890.000 | Oberbauschotter | Erdbau | 900 | 890 | Oberbauschotter-Gleis-2 | OEBBset_Semantik_Topologie - 34_Elementtyp: ND; 35_Instandhaltungsbezeichnung: ND; OEBBset_Schotterbett - MinSchotterbettbreite: 3,60; MinSchotterbettstaerke: 0,50; Koernung: Klasse 1; IstGewaschen: Ja; ProVI - PVI_VOLUMEN_REB_M3: 29.19; PVI_VOLUMEN_M3: 29.19; PVI_SCHICHTSTAERKE: 0; PVI_FLAECHE_M2: 56.907; OEBBset_RC2_KE - Vorhabenteil: Some Value; Elementbezeichnung: Some Value; vonkm_RC2: Some Value; biskm_RC2: Some Value; Länge_RC2: Some Value; Breite_RC2: Some Value; Höhe_RC2: Some Value; Fläche_RC2: Some Value; Volumen_RC2: Some Value; DichteT_RC2: Some Value; MasseT_RC2: Some Value; DichteKG_RC2: Some Value; MasseKG_RC2: Some Value; DauerT_RC2: Some Value; DauerH_RC2: Some Value
2 x Schiene | Schiene | 0,780.000 | Gleis | 0,779.500 | Schiene | Oberbau | 780 | 779.5 | Schiene | 0.172 | 60E1 | Gleis 2 | 0.5
2 x Schiene | Schiene | 0,790.000 | Gleis | 0,780.000 | Schiene | Oberbau | 790 | 780 | Schiene | 0.172 | 60E1 | Gleis 2 | 10
2 x Schiene | Schiene | 0,800.000 | Gleis | 0,790.000 | Schiene | Oberbau | 800 | 790 | Schiene | 0.172 | 60E1 | Gleis 2 | 10
2 x Schiene | Schiene | 0,810.000 | Gleis | 0,800.000 | Schiene | Oberbau | 810 | 800 | Schiene | 0.172 | 60E1 | Gleis 2 | 10
2 x Schiene | Schiene | 0,820.000 | Gleis | 0,810.000 | Schiene | Oberbau | 820 | 810 | Schiene | 0.172 | 60E1 | Gleis 2 | 10
2 x Schiene | Schiene | 0,830.000 | Gleis | 0,820.000 | Schiene | Oberbau | 830 | 820 | Schiene | 0.172 | 60E1 | Gleis 2 | 10
2 x Schiene | Schiene | 0,840.000 | Gleis | 0,830.000 | Schiene | Oberbau | 840 | 830 | Schiene | 0.172 | 60E1 | Gleis 2 | 10
2 x Schiene | Schiene | 0,850.000 | Gleis | 0,840.000 | Schiene | Oberbau | 850 | 840 | Schiene | 0.172 | 60E1 | Gleis 2 | 10
2 x Schiene | Schiene | 0,860.000 | Gleis | 0,850.000 | Schiene | Oberbau | 860 | 850 | Schiene | 0.172 | 60E1 | Gleis 2 | 10
2 x Schiene | Schiene | 0,870.000 | Gleis | 0,860.000 | Schiene | Oberbau | 870 | 860 | Schiene | 0.172 | 60E1 | Gleis 2 | 10
2 x Schiene | Schiene | 0,880.000 | Gleis | 0,870.000 | Schiene | Oberbau | 880 | 870 | Schiene | 0.172 | 60E1 | Gleis 2 | 10
2 x Schiene | Schiene | 0,890.000 | Gleis | 0,880.000 | Schiene | Oberbau | 890 | 880 | Schiene | 0.172 | 60E1 | Gleis 2 | 10
2 x Schiene | Schiene | 0,900.000 | Gleis | 0,890.000 | Schiene | Oberbau | 900 | 890 | Schiene | 0.172 | 60E1 | Gleis 2 | 10
2 x Schiene | Schiene | 0,780.000 | Gleis | 0,779.500 | Schiene | Oberbau | 780 | 779.5 | Schiene | 0.172 | 60E1 | Gleis 1 | 0.5
2 x Schiene | Schiene | 0,790.000 | Gleis | 0,780.000 | Schiene | Oberbau | 790 | 780 | Schiene | 0.172 | 60E1 | Gleis 1 | 10
2 x Schiene | Schiene | 0,800.000 | Gleis | 0,790.000 | Schiene | Oberbau | 800 | 790 | Schiene | 0.172 | 60E1 | Gleis 1 | 10
2 x Schiene | Schiene | 0,810.000 | Gleis | 0,800.000 | Schiene | Oberbau | 810 | 800 | Schiene | 0.172 | 60E1 | Gleis 1 | 10
2 x Schiene | Schiene | 0,820.000 | Gleis | 0,810.000 | Schiene | Oberbau | 820 | 810 | Schiene | 0.172 | 60E1 | Gleis 1 | 10
2 x Schiene | Schiene | 0,830.000 | Gleis | 0,820.000 | Schiene | Oberbau | 830 | 820 | Schiene | 0.172 | 60E1 | Gleis 1 | 10
2 x Schiene | Schiene | 0,840.000 | Gleis | 0,830.000 | Schiene | Oberbau | 840 | 830 | Schiene | 0.172 | 60E1 | Gleis 1 | 10
2 x Schiene | Schiene | 0,850.000 | Gleis | 0,840.000 | Schiene | Oberbau | 850 | 840 | Schiene | 0.172 | 60E1 | Gleis 1 | 10
2 x Schiene | Schiene | 0,860.000 | Gleis | 0,850.000 | Schiene | Oberbau | 860 | 850 | Schiene | 0.172 | 60E1 | Gleis 1 | 10
2 x Schiene | Schiene | 0,870.000 | Gleis | 0,860.000 | Schiene | Oberbau | 870 | 860 | Schiene | 0.172 | 60E1 | Gleis 1 | 10
2 x Schiene | Schiene | 0,880.000 | Gleis | 0,870.000 | Schiene | Oberbau | 880 | 870 | Schiene | 0.172 | 60E1 | Gleis 1 | 10
2 x Schiene | Schiene | 0,890.000 | Gleis | 0,880.000 | Schiene | Oberbau | 890 | 880 | Schiene | 0.172 | 60E1 | Gleis 1 | 10
2 x Schiene | Schiene | 0,900.000 | Gleis | 0,890.000 | Schiene | Oberbau | 900 | 890 | Schiene | 0.172 | 60E1 | Gleis 1 | 10
Schwelle | Schwelle | 0,779.700 | Gleis | 0,779.700 | Schwelle | Oberbau | 779.7 | 779.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,780.300 | Gleis | 0,780.300 | Schwelle | Oberbau | 780.3 | 780.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,780.900 | Gleis | 0,780.900 | Schwelle | Oberbau | 780.9 | 780.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,781.500 | Gleis | 0,781.500 | Schwelle | Oberbau | 781.5 | 781.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,782.100 | Gleis | 0,782.100 | Schwelle | Oberbau | 782.1 | 782.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,782.700 | Gleis | 0,782.700 | Schwelle | Oberbau | 782.7 | 782.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,783.300 | Gleis | 0,783.300 | Schwelle | Oberbau | 783.3 | 783.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,783.900 | Gleis | 0,783.900 | Schwelle | Oberbau | 783.9 | 783.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,784.500 | Gleis | 0,784.500 | Schwelle | Oberbau | 784.5 | 784.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,785.100 | Gleis | 0,785.100 | Schwelle | Oberbau | 785.1 | 785.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,785.700 | Gleis | 0,785.700 | Schwelle | Oberbau | 785.7 | 785.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,786.300 | Gleis | 0,786.300 | Schwelle | Oberbau | 786.3 | 786.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,786.900 | Gleis | 0,786.900 | Schwelle | Oberbau | 786.9 | 786.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,787.500 | Gleis | 0,787.500 | Schwelle | Oberbau | 787.5 | 787.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,788.100 | Gleis | 0,788.100 | Schwelle | Oberbau | 788.1 | 788.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,788.700 | Gleis | 0,788.700 | Schwelle | Oberbau | 788.7 | 788.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,789.300 | Gleis | 0,789.300 | Schwelle | Oberbau | 789.3 | 789.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,789.900 | Gleis | 0,789.900 | Schwelle | Oberbau | 789.9 | 789.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,790.500 | Gleis | 0,790.500 | Schwelle | Oberbau | 790.5 | 790.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,791.100 | Gleis | 0,791.100 | Schwelle | Oberbau | 791.1 | 791.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,791.700 | Gleis | 0,791.700 | Schwelle | Oberbau | 791.7 | 791.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,792.300 | Gleis | 0,792.300 | Schwelle | Oberbau | 792.3 | 792.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,792.900 | Gleis | 0,792.900 | Schwelle | Oberbau | 792.9 | 792.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,793.500 | Gleis | 0,793.500 | Schwelle | Oberbau | 793.5 | 793.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,794.100 | Gleis | 0,794.100 | Schwelle | Oberbau | 794.1 | 794.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,794.700 | Gleis | 0,794.700 | Schwelle | Oberbau | 794.7 | 794.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,795.300 | Gleis | 0,795.300 | Schwelle | Oberbau | 795.3 | 795.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,795.900 | Gleis | 0,795.900 | Schwelle | Oberbau | 795.9 | 795.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,796.500 | Gleis | 0,796.500 | Schwelle | Oberbau | 796.5 | 796.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,797.100 | Gleis | 0,797.100 | Schwelle | Oberbau | 797.1 | 797.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,797.700 | Gleis | 0,797.700 | Schwelle | Oberbau | 797.7 | 797.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,798.300 | Gleis | 0,798.300 | Schwelle | Oberbau | 798.3 | 798.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,798.900 | Gleis | 0,798.900 | Schwelle | Oberbau | 798.9 | 798.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,799.500 | Gleis | 0,799.500 | Schwelle | Oberbau | 799.5 | 799.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,800.100 | Gleis | 0,800.100 | Schwelle | Oberbau | 800.1 | 800.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,800.700 | Gleis | 0,800.700 | Schwelle | Oberbau | 800.7 | 800.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,801.300 | Gleis | 0,801.300 | Schwelle | Oberbau | 801.3 | 801.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,801.900 | Gleis | 0,801.900 | Schwelle | Oberbau | 801.9 | 801.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,802.500 | Gleis | 0,802.500 | Schwelle | Oberbau | 802.5 | 802.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,803.100 | Gleis | 0,803.100 | Schwelle | Oberbau | 803.1 | 803.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,803.700 | Gleis | 0,803.700 | Schwelle | Oberbau | 803.7 | 803.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,804.300 | Gleis | 0,804.300 | Schwelle | Oberbau | 804.3 | 804.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,804.900 | Gleis | 0,804.900 | Schwelle | Oberbau | 804.9 | 804.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,805.500 | Gleis | 0,805.500 | Schwelle | Oberbau | 805.5 | 805.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,806.100 | Gleis | 0,806.100 | Schwelle | Oberbau | 806.1 | 806.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,806.700 | Gleis | 0,806.700 | Schwelle | Oberbau | 806.7 | 806.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,807.300 | Gleis | 0,807.300 | Schwelle | Oberbau | 807.3 | 807.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,807.900 | Gleis | 0,807.900 | Schwelle | Oberbau | 807.9 | 807.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,808.500 | Gleis | 0,808.500 | Schwelle | Oberbau | 808.5 | 808.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,809.100 | Gleis | 0,809.100 | Schwelle | Oberbau | 809.1 | 809.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,809.700 | Gleis | 0,809.700 | Schwelle | Oberbau | 809.7 | 809.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,810.300 | Gleis | 0,810.300 | Schwelle | Oberbau | 810.3 | 810.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,810.900 | Gleis | 0,810.900 | Schwelle | Oberbau | 810.9 | 810.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,811.500 | Gleis | 0,811.500 | Schwelle | Oberbau | 811.5 | 811.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,812.100 | Gleis | 0,812.100 | Schwelle | Oberbau | 812.1 | 812.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,812.700 | Gleis | 0,812.700 | Schwelle | Oberbau | 812.7 | 812.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,813.300 | Gleis | 0,813.300 | Schwelle | Oberbau | 813.3 | 813.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,813.900 | Gleis | 0,813.900 | Schwelle | Oberbau | 813.9 | 813.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,814.500 | Gleis | 0,814.500 | Schwelle | Oberbau | 814.5 | 814.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,815.100 | Gleis | 0,815.100 | Schwelle | Oberbau | 815.1 | 815.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,815.700 | Gleis | 0,815.700 | Schwelle | Oberbau | 815.7 | 815.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,816.300 | Gleis | 0,816.300 | Schwelle | Oberbau | 816.3 | 816.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,816.900 | Gleis | 0,816.900 | Schwelle | Oberbau | 816.9 | 816.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,817.500 | Gleis | 0,817.500 | Schwelle | Oberbau | 817.5 | 817.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,818.100 | Gleis | 0,818.100 | Schwelle | Oberbau | 818.1 | 818.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,818.700 | Gleis | 0,818.700 | Schwelle | Oberbau | 818.7 | 818.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,819.300 | Gleis | 0,819.300 | Schwelle | Oberbau | 819.3 | 819.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,819.900 | Gleis | 0,819.900 | Schwelle | Oberbau | 819.9 | 819.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,820.500 | Gleis | 0,820.500 | Schwelle | Oberbau | 820.5 | 820.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,821.100 | Gleis | 0,821.100 | Schwelle | Oberbau | 821.1 | 821.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,821.700 | Gleis | 0,821.700 | Schwelle | Oberbau | 821.7 | 821.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,822.300 | Gleis | 0,822.300 | Schwelle | Oberbau | 822.3 | 822.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,822.900 | Gleis | 0,822.900 | Schwelle | Oberbau | 822.9 | 822.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,823.500 | Gleis | 0,823.500 | Schwelle | Oberbau | 823.5 | 823.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,824.100 | Gleis | 0,824.100 | Schwelle | Oberbau | 824.1 | 824.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,824.700 | Gleis | 0,824.700 | Schwelle | Oberbau | 824.7 | 824.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,825.300 | Gleis | 0,825.300 | Schwelle | Oberbau | 825.3 | 825.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,825.900 | Gleis | 0,825.900 | Schwelle | Oberbau | 825.9 | 825.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,826.500 | Gleis | 0,826.500 | Schwelle | Oberbau | 826.5 | 826.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,827.100 | Gleis | 0,827.100 | Schwelle | Oberbau | 827.1 | 827.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,827.700 | Gleis | 0,827.700 | Schwelle | Oberbau | 827.7 | 827.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,828.300 | Gleis | 0,828.300 | Schwelle | Oberbau | 828.3 | 828.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,828.900 | Gleis | 0,828.900 | Schwelle | Oberbau | 828.9 | 828.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,829.500 | Gleis | 0,829.500 | Schwelle | Oberbau | 829.5 | 829.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,830.100 | Gleis | 0,830.100 | Schwelle | Oberbau | 830.1 | 830.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,830.700 | Gleis | 0,830.700 | Schwelle | Oberbau | 830.7 | 830.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,831.300 | Gleis | 0,831.300 | Schwelle | Oberbau | 831.3 | 831.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,831.900 | Gleis | 0,831.900 | Schwelle | Oberbau | 831.9 | 831.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,832.500 | Gleis | 0,832.500 | Schwelle | Oberbau | 832.5 | 832.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,833.100 | Gleis | 0,833.100 | Schwelle | Oberbau | 833.1 | 833.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,833.700 | Gleis | 0,833.700 | Schwelle | Oberbau | 833.7 | 833.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,834.300 | Gleis | 0,834.300 | Schwelle | Oberbau | 834.3 | 834.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,834.900 | Gleis | 0,834.900 | Schwelle | Oberbau | 834.9 | 834.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,835.500 | Gleis | 0,835.500 | Schwelle | Oberbau | 835.5 | 835.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,836.100 | Gleis | 0,836.100 | Schwelle | Oberbau | 836.1 | 836.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,836.700 | Gleis | 0,836.700 | Schwelle | Oberbau | 836.7 | 836.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,837.300 | Gleis | 0,837.300 | Schwelle | Oberbau | 837.3 | 837.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,837.900 | Gleis | 0,837.900 | Schwelle | Oberbau | 837.9 | 837.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,838.500 | Gleis | 0,838.500 | Schwelle | Oberbau | 838.5 | 838.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,839.100 | Gleis | 0,839.100 | Schwelle | Oberbau | 839.1 | 839.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,839.700 | Gleis | 0,839.700 | Schwelle | Oberbau | 839.7 | 839.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,840.300 | Gleis | 0,840.300 | Schwelle | Oberbau | 840.3 | 840.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,840.900 | Gleis | 0,840.900 | Schwelle | Oberbau | 840.9 | 840.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,841.500 | Gleis | 0,841.500 | Schwelle | Oberbau | 841.5 | 841.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,842.100 | Gleis | 0,842.100 | Schwelle | Oberbau | 842.1 | 842.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,842.700 | Gleis | 0,842.700 | Schwelle | Oberbau | 842.7 | 842.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,843.300 | Gleis | 0,843.300 | Schwelle | Oberbau | 843.3 | 843.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,843.900 | Gleis | 0,843.900 | Schwelle | Oberbau | 843.9 | 843.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,844.500 | Gleis | 0,844.500 | Schwelle | Oberbau | 844.5 | 844.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,845.100 | Gleis | 0,845.100 | Schwelle | Oberbau | 845.1 | 845.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,845.700 | Gleis | 0,845.700 | Schwelle | Oberbau | 845.7 | 845.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,846.300 | Gleis | 0,846.300 | Schwelle | Oberbau | 846.3 | 846.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,846.900 | Gleis | 0,846.900 | Schwelle | Oberbau | 846.9 | 846.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,847.500 | Gleis | 0,847.500 | Schwelle | Oberbau | 847.5 | 847.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,848.100 | Gleis | 0,848.100 | Schwelle | Oberbau | 848.1 | 848.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,848.700 | Gleis | 0,848.700 | Schwelle | Oberbau | 848.7 | 848.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,849.300 | Gleis | 0,849.300 | Schwelle | Oberbau | 849.3 | 849.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,849.900 | Gleis | 0,849.900 | Schwelle | Oberbau | 849.9 | 849.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,850.500 | Gleis | 0,850.500 | Schwelle | Oberbau | 850.5 | 850.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,851.100 | Gleis | 0,851.100 | Schwelle | Oberbau | 851.1 | 851.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,851.700 | Gleis | 0,851.700 | Schwelle | Oberbau | 851.7 | 851.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,852.300 | Gleis | 0,852.300 | Schwelle | Oberbau | 852.3 | 852.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,852.900 | Gleis | 0,852.900 | Schwelle | Oberbau | 852.9 | 852.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,853.500 | Gleis | 0,853.500 | Schwelle | Oberbau | 853.5 | 853.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,854.100 | Gleis | 0,854.100 | Schwelle | Oberbau | 854.1 | 854.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,854.700 | Gleis | 0,854.700 | Schwelle | Oberbau | 854.7 | 854.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,855.300 | Gleis | 0,855.300 | Schwelle | Oberbau | 855.3 | 855.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,855.900 | Gleis | 0,855.900 | Schwelle | Oberbau | 855.9 | 855.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,856.500 | Gleis | 0,856.500 | Schwelle | Oberbau | 856.5 | 856.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,857.100 | Gleis | 0,857.100 | Schwelle | Oberbau | 857.1 | 857.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,857.700 | Gleis | 0,857.700 | Schwelle | Oberbau | 857.7 | 857.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,858.300 | Gleis | 0,858.300 | Schwelle | Oberbau | 858.3 | 858.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,858.900 | Gleis | 0,858.900 | Schwelle | Oberbau | 858.9 | 858.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,859.500 | Gleis | 0,859.500 | Schwelle | Oberbau | 859.5 | 859.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,860.100 | Gleis | 0,860.100 | Schwelle | Oberbau | 860.1 | 860.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,860.700 | Gleis | 0,860.700 | Schwelle | Oberbau | 860.7 | 860.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,861.300 | Gleis | 0,861.300 | Schwelle | Oberbau | 861.3 | 861.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,861.900 | Gleis | 0,861.900 | Schwelle | Oberbau | 861.9 | 861.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,862.500 | Gleis | 0,862.500 | Schwelle | Oberbau | 862.5 | 862.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,863.100 | Gleis | 0,863.100 | Schwelle | Oberbau | 863.1 | 863.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,863.700 | Gleis | 0,863.700 | Schwelle | Oberbau | 863.7 | 863.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,864.300 | Gleis | 0,864.300 | Schwelle | Oberbau | 864.3 | 864.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,864.900 | Gleis | 0,864.900 | Schwelle | Oberbau | 864.9 | 864.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,865.500 | Gleis | 0,865.500 | Schwelle | Oberbau | 865.5 | 865.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,866.100 | Gleis | 0,866.100 | Schwelle | Oberbau | 866.1 | 866.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,866.700 | Gleis | 0,866.700 | Schwelle | Oberbau | 866.7 | 866.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,867.300 | Gleis | 0,867.300 | Schwelle | Oberbau | 867.3 | 867.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,867.900 | Gleis | 0,867.900 | Schwelle | Oberbau | 867.9 | 867.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,868.500 | Gleis | 0,868.500 | Schwelle | Oberbau | 868.5 | 868.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,869.100 | Gleis | 0,869.100 | Schwelle | Oberbau | 869.1 | 869.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,869.700 | Gleis | 0,869.700 | Schwelle | Oberbau | 869.7 | 869.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,870.300 | Gleis | 0,870.300 | Schwelle | Oberbau | 870.3 | 870.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,870.900 | Gleis | 0,870.900 | Schwelle | Oberbau | 870.9 | 870.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,871.500 | Gleis | 0,871.500 | Schwelle | Oberbau | 871.5 | 871.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,872.100 | Gleis | 0,872.100 | Schwelle | Oberbau | 872.1 | 872.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,872.700 | Gleis | 0,872.700 | Schwelle | Oberbau | 872.7 | 872.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,873.300 | Gleis | 0,873.300 | Schwelle | Oberbau | 873.3 | 873.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,873.900 | Gleis | 0,873.900 | Schwelle | Oberbau | 873.9 | 873.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,874.500 | Gleis | 0,874.500 | Schwelle | Oberbau | 874.5 | 874.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,875.100 | Gleis | 0,875.100 | Schwelle | Oberbau | 875.1 | 875.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,875.700 | Gleis | 0,875.700 | Schwelle | Oberbau | 875.7 | 875.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,876.300 | Gleis | 0,876.300 | Schwelle | Oberbau | 876.3 | 876.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,876.900 | Gleis | 0,876.900 | Schwelle | Oberbau | 876.9 | 876.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,877.500 | Gleis | 0,877.500 | Schwelle | Oberbau | 877.5 | 877.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,878.100 | Gleis | 0,878.100 | Schwelle | Oberbau | 878.1 | 878.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,878.700 | Gleis | 0,878.700 | Schwelle | Oberbau | 878.7 | 878.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,879.300 | Gleis | 0,879.300 | Schwelle | Oberbau | 879.3 | 879.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,879.900 | Gleis | 0,879.900 | Schwelle | Oberbau | 879.9 | 879.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,880.500 | Gleis | 0,880.500 | Schwelle | Oberbau | 880.5 | 880.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,881.100 | Gleis | 0,881.100 | Schwelle | Oberbau | 881.1 | 881.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,881.700 | Gleis | 0,881.700 | Schwelle | Oberbau | 881.7 | 881.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,882.300 | Gleis | 0,882.300 | Schwelle | Oberbau | 882.3 | 882.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,882.900 | Gleis | 0,882.900 | Schwelle | Oberbau | 882.9 | 882.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,883.500 | Gleis | 0,883.500 | Schwelle | Oberbau | 883.5 | 883.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,884.100 | Gleis | 0,884.100 | Schwelle | Oberbau | 884.1 | 884.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,884.700 | Gleis | 0,884.700 | Schwelle | Oberbau | 884.7 | 884.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,885.300 | Gleis | 0,885.300 | Schwelle | Oberbau | 885.3 | 885.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,885.900 | Gleis | 0,885.900 | Schwelle | Oberbau | 885.9 | 885.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,886.500 | Gleis | 0,886.500 | Schwelle | Oberbau | 886.5 | 886.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,887.100 | Gleis | 0,887.100 | Schwelle | Oberbau | 887.1 | 887.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,887.700 | Gleis | 0,887.700 | Schwelle | Oberbau | 887.7 | 887.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,888.300 | Gleis | 0,888.300 | Schwelle | Oberbau | 888.3 | 888.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,888.900 | Gleis | 0,888.900 | Schwelle | Oberbau | 888.9 | 888.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,889.500 | Gleis | 0,889.500 | Schwelle | Oberbau | 889.5 | 889.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,890.100 | Gleis | 0,890.100 | Schwelle | Oberbau | 890.1 | 890.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,890.700 | Gleis | 0,890.700 | Schwelle | Oberbau | 890.7 | 890.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,891.300 | Gleis | 0,891.300 | Schwelle | Oberbau | 891.3 | 891.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,891.900 | Gleis | 0,891.900 | Schwelle | Oberbau | 891.9 | 891.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,892.500 | Gleis | 0,892.500 | Schwelle | Oberbau | 892.5 | 892.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,893.100 | Gleis | 0,893.100 | Schwelle | Oberbau | 893.1 | 893.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,893.700 | Gleis | 0,893.700 | Schwelle | Oberbau | 893.7 | 893.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,894.300 | Gleis | 0,894.300 | Schwelle | Oberbau | 894.3 | 894.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,894.900 | Gleis | 0,894.900 | Schwelle | Oberbau | 894.9 | 894.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,895.500 | Gleis | 0,895.500 | Schwelle | Oberbau | 895.5 | 895.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,896.100 | Gleis | 0,896.100 | Schwelle | Oberbau | 896.1 | 896.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,896.700 | Gleis | 0,896.700 | Schwelle | Oberbau | 896.7 | 896.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,897.300 | Gleis | 0,897.300 | Schwelle | Oberbau | 897.3 | 897.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,897.900 | Gleis | 0,897.900 | Schwelle | Oberbau | 897.9 | 897.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,898.500 | Gleis | 0,898.500 | Schwelle | Oberbau | 898.5 | 898.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,899.100 | Gleis | 0,899.100 | Schwelle | Oberbau | 899.1 | 899.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,899.700 | Gleis | 0,899.700 | Schwelle | Oberbau | 899.7 | 899.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 2 | 0.3 | 2.6
Schwelle | Schwelle | 0,779.700 | Gleis | 0,779.700 | Schwelle | Oberbau | 779.7 | 779.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,780.300 | Gleis | 0,780.300 | Schwelle | Oberbau | 780.3 | 780.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,780.900 | Gleis | 0,780.900 | Schwelle | Oberbau | 780.9 | 780.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,781.500 | Gleis | 0,781.500 | Schwelle | Oberbau | 781.5 | 781.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,782.100 | Gleis | 0,782.100 | Schwelle | Oberbau | 782.1 | 782.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,782.700 | Gleis | 0,782.700 | Schwelle | Oberbau | 782.7 | 782.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,783.300 | Gleis | 0,783.300 | Schwelle | Oberbau | 783.3 | 783.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,783.900 | Gleis | 0,783.900 | Schwelle | Oberbau | 783.9 | 783.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,784.500 | Gleis | 0,784.500 | Schwelle | Oberbau | 784.5 | 784.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,785.100 | Gleis | 0,785.100 | Schwelle | Oberbau | 785.1 | 785.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,785.700 | Gleis | 0,785.700 | Schwelle | Oberbau | 785.7 | 785.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,786.300 | Gleis | 0,786.300 | Schwelle | Oberbau | 786.3 | 786.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,786.900 | Gleis | 0,786.900 | Schwelle | Oberbau | 786.9 | 786.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,787.500 | Gleis | 0,787.500 | Schwelle | Oberbau | 787.5 | 787.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,788.100 | Gleis | 0,788.100 | Schwelle | Oberbau | 788.1 | 788.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,788.700 | Gleis | 0,788.700 | Schwelle | Oberbau | 788.7 | 788.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,789.300 | Gleis | 0,789.300 | Schwelle | Oberbau | 789.3 | 789.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,789.900 | Gleis | 0,789.900 | Schwelle | Oberbau | 789.9 | 789.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,790.500 | Gleis | 0,790.500 | Schwelle | Oberbau | 790.5 | 790.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,791.100 | Gleis | 0,791.100 | Schwelle | Oberbau | 791.1 | 791.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,791.700 | Gleis | 0,791.700 | Schwelle | Oberbau | 791.7 | 791.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,792.300 | Gleis | 0,792.300 | Schwelle | Oberbau | 792.3 | 792.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,792.900 | Gleis | 0,792.900 | Schwelle | Oberbau | 792.9 | 792.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,793.500 | Gleis | 0,793.500 | Schwelle | Oberbau | 793.5 | 793.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,794.100 | Gleis | 0,794.100 | Schwelle | Oberbau | 794.1 | 794.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,794.700 | Gleis | 0,794.700 | Schwelle | Oberbau | 794.7 | 794.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,795.300 | Gleis | 0,795.300 | Schwelle | Oberbau | 795.3 | 795.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,795.900 | Gleis | 0,795.900 | Schwelle | Oberbau | 795.9 | 795.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,796.500 | Gleis | 0,796.500 | Schwelle | Oberbau | 796.5 | 796.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,797.100 | Gleis | 0,797.100 | Schwelle | Oberbau | 797.1 | 797.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,797.700 | Gleis | 0,797.700 | Schwelle | Oberbau | 797.7 | 797.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,798.300 | Gleis | 0,798.300 | Schwelle | Oberbau | 798.3 | 798.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,798.900 | Gleis | 0,798.900 | Schwelle | Oberbau | 798.9 | 798.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,799.500 | Gleis | 0,799.500 | Schwelle | Oberbau | 799.5 | 799.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,800.100 | Gleis | 0,800.100 | Schwelle | Oberbau | 800.1 | 800.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,800.700 | Gleis | 0,800.700 | Schwelle | Oberbau | 800.7 | 800.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,801.300 | Gleis | 0,801.300 | Schwelle | Oberbau | 801.3 | 801.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,801.900 | Gleis | 0,801.900 | Schwelle | Oberbau | 801.9 | 801.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,802.500 | Gleis | 0,802.500 | Schwelle | Oberbau | 802.5 | 802.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,803.100 | Gleis | 0,803.100 | Schwelle | Oberbau | 803.1 | 803.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,803.700 | Gleis | 0,803.700 | Schwelle | Oberbau | 803.7 | 803.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,804.300 | Gleis | 0,804.300 | Schwelle | Oberbau | 804.3 | 804.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,804.900 | Gleis | 0,804.900 | Schwelle | Oberbau | 804.9 | 804.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,805.500 | Gleis | 0,805.500 | Schwelle | Oberbau | 805.5 | 805.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,806.100 | Gleis | 0,806.100 | Schwelle | Oberbau | 806.1 | 806.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,806.700 | Gleis | 0,806.700 | Schwelle | Oberbau | 806.7 | 806.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,807.300 | Gleis | 0,807.300 | Schwelle | Oberbau | 807.3 | 807.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,807.900 | Gleis | 0,807.900 | Schwelle | Oberbau | 807.9 | 807.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,808.500 | Gleis | 0,808.500 | Schwelle | Oberbau | 808.5 | 808.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,809.100 | Gleis | 0,809.100 | Schwelle | Oberbau | 809.1 | 809.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,809.700 | Gleis | 0,809.700 | Schwelle | Oberbau | 809.7 | 809.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,810.300 | Gleis | 0,810.300 | Schwelle | Oberbau | 810.3 | 810.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,810.900 | Gleis | 0,810.900 | Schwelle | Oberbau | 810.9 | 810.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,811.500 | Gleis | 0,811.500 | Schwelle | Oberbau | 811.5 | 811.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,812.100 | Gleis | 0,812.100 | Schwelle | Oberbau | 812.1 | 812.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,812.700 | Gleis | 0,812.700 | Schwelle | Oberbau | 812.7 | 812.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,813.300 | Gleis | 0,813.300 | Schwelle | Oberbau | 813.3 | 813.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,813.900 | Gleis | 0,813.900 | Schwelle | Oberbau | 813.9 | 813.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,814.500 | Gleis | 0,814.500 | Schwelle | Oberbau | 814.5 | 814.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,815.100 | Gleis | 0,815.100 | Schwelle | Oberbau | 815.1 | 815.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,815.700 | Gleis | 0,815.700 | Schwelle | Oberbau | 815.7 | 815.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,816.300 | Gleis | 0,816.300 | Schwelle | Oberbau | 816.3 | 816.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,816.900 | Gleis | 0,816.900 | Schwelle | Oberbau | 816.9 | 816.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,817.500 | Gleis | 0,817.500 | Schwelle | Oberbau | 817.5 | 817.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,818.100 | Gleis | 0,818.100 | Schwelle | Oberbau | 818.1 | 818.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,818.700 | Gleis | 0,818.700 | Schwelle | Oberbau | 818.7 | 818.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,819.300 | Gleis | 0,819.300 | Schwelle | Oberbau | 819.3 | 819.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,819.900 | Gleis | 0,819.900 | Schwelle | Oberbau | 819.9 | 819.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,820.500 | Gleis | 0,820.500 | Schwelle | Oberbau | 820.5 | 820.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,821.100 | Gleis | 0,821.100 | Schwelle | Oberbau | 821.1 | 821.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,821.700 | Gleis | 0,821.700 | Schwelle | Oberbau | 821.7 | 821.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,822.300 | Gleis | 0,822.300 | Schwelle | Oberbau | 822.3 | 822.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,822.900 | Gleis | 0,822.900 | Schwelle | Oberbau | 822.9 | 822.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,823.500 | Gleis | 0,823.500 | Schwelle | Oberbau | 823.5 | 823.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,824.100 | Gleis | 0,824.100 | Schwelle | Oberbau | 824.1 | 824.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,824.700 | Gleis | 0,824.700 | Schwelle | Oberbau | 824.7 | 824.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,825.300 | Gleis | 0,825.300 | Schwelle | Oberbau | 825.3 | 825.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,825.900 | Gleis | 0,825.900 | Schwelle | Oberbau | 825.9 | 825.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,826.500 | Gleis | 0,826.500 | Schwelle | Oberbau | 826.5 | 826.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,827.100 | Gleis | 0,827.100 | Schwelle | Oberbau | 827.1 | 827.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,827.700 | Gleis | 0,827.700 | Schwelle | Oberbau | 827.7 | 827.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,828.300 | Gleis | 0,828.300 | Schwelle | Oberbau | 828.3 | 828.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,828.900 | Gleis | 0,828.900 | Schwelle | Oberbau | 828.9 | 828.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,829.500 | Gleis | 0,829.500 | Schwelle | Oberbau | 829.5 | 829.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,830.100 | Gleis | 0,830.100 | Schwelle | Oberbau | 830.1 | 830.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,830.700 | Gleis | 0,830.700 | Schwelle | Oberbau | 830.7 | 830.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,831.300 | Gleis | 0,831.300 | Schwelle | Oberbau | 831.3 | 831.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
