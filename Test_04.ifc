Properties of the parts of a building model (IFC4), part 2 of 2

# IfcBuildingElementProxy (480)
Name | In | 42_kmEnde = PVI_KM_BIS_001P = PVI_KM_BIS | 24_Topologie_Ebene_3 | 41_kmAnfang = PVI_KM_VON = PVI_KM_VON_001P | 32_Element | PVI_BAUTEILGRUPPE | PVI_STAT_BIS = PVI_STAT_BIS_001P | PVI_STAT_VON = PVI_STAT_VON_001P | PVI_BAUTEILTYP | PVI_ELEMENT_HOEHE | PVI_TYP | PVI_BEZEICHNUNG_GLEIS | PVI_ELEMENT_LAENGE | PVI_ELEMENT_BREITE
Schwelle | Schwelle | 0,831.900 | Gleis | 0,831.900 | Schwelle | Oberbau | 831.9 | 831.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,832.500 | Gleis | 0,832.500 | Schwelle | Oberbau | 832.5 | 832.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,833.100 | Gleis | 0,833.100 | Schwelle | Oberbau | 833.1 | 833.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,833.700 | Gleis | 0,833.700 | Schwelle | Oberbau | 833.7 | 833.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,834.300 | Gleis | 0,834.300 | Schwelle | Oberbau | 834.3 | 834.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,834.900 | Gleis | 0,834.900 | Schwelle | Oberbau | 834.9 | 834.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,835.500 | Gleis | 0,835.500 | Schwelle | Oberbau | 835.5 | 835.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,836.100 | Gleis | 0,836.100 | Schwelle | Oberbau | 836.1 | 836.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,836.700 | Gleis | 0,836.700 | Schwelle | Oberbau | 836.7 | 836.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,837.300 | Gleis | 0,837.300 | Schwelle | Oberbau | 837.3 | 837.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,837.900 | Gleis | 0,837.900 | Schwelle | Oberbau | 837.9 | 837.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,838.500 | Gleis | 0,838.500 | Schwelle | Oberbau | 838.5 | 838.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,839.100 | Gleis | 0,839.100 | Schwelle | Oberbau | 839.1 | 839.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,839.700 | Gleis | 0,839.700 | Schwelle | Oberbau | 839.7 | 839.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,840.300 | Gleis | 0,840.300 | Schwelle | Oberbau | 840.3 | 840.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,840.900 | Gleis | 0,840.900 | Schwelle | Oberbau | 840.9 | 840.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,841.500 | Gleis | 0,841.500 | Schwelle | Oberbau | 841.5 | 841.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,842.100 | Gleis | 0,842.100 | Schwelle | Oberbau | 842.1 | 842.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,842.700 | Gleis | 0,842.700 | Schwelle | Oberbau | 842.7 | 842.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,843.300 | Gleis | 0,843.300 | Schwelle | Oberbau | 843.3 | 843.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,843.900 | Gleis | 0,843.900 | Schwelle | Oberbau | 843.9 | 843.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,844.500 | Gleis | 0,844.500 | Schwelle | Oberbau | 844.5 | 844.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,845.100 | Gleis | 0,845.100 | Schwelle | Oberbau | 845.1 | 845.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,845.700 | Gleis | 0,845.700 | Schwelle | Oberbau | 845.7 | 845.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,846.300 | Gleis | 0,846.300 | Schwelle | Oberbau | 846.3 | 846.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,846.900 | Gleis | 0,846.900 | Schwelle | Oberbau | 846.9 | 846.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,847.500 | Gleis | 0,847.500 | Schwelle | Oberbau | 847.5 | 847.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,848.100 | Gleis | 0,848.100 | Schwelle | Oberbau | 848.1 | 848.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,848.700 | Gleis | 0,848.700 | Schwelle | Oberbau | 848.7 | 848.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,849.300 | Gleis | 0,849.300 | Schwelle | Oberbau | 849.3 | 849.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,849.900 | Gleis | 0,849.900 | Schwelle | Oberbau | 849.9 | 849.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,850.500 | Gleis | 0,850.500 | Schwelle | Oberbau | 850.5 | 850.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,851.100 | Gleis | 0,851.100 | Schwelle | Oberbau | 851.1 | 851.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,851.700 | Gleis | 0,851.700 | Schwelle | Oberbau | 851.7 | 851.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,852.300 | Gleis | 0,852.300 | Schwelle | Oberbau | 852.3 | 852.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,852.900 | Gleis | 0,852.900 | Schwelle | Oberbau | 852.9 | 852.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,853.500 | Gleis | 0,853.500 | Schwelle | Oberbau | 853.5 | 853.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,854.100 | Gleis | 0,854.100 | Schwelle | Oberbau | 854.1 | 854.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,854.700 | Gleis | 0,854.700 | Schwelle | Oberbau | 854.7 | 854.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,855.300 | Gleis | 0,855.300 | Schwelle | Oberbau | 855.3 | 855.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,855.900 | Gleis | 0,855.900 | Schwelle | Oberbau | 855.9 | 855.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,856.500 | Gleis | 0,856.500 | Schwelle | Oberbau | 856.5 | 856.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,857.100 | Gleis | 0,857.100 | Schwelle | Oberbau | 857.1 | 857.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,857.700 | Gleis | 0,857.700 | Schwelle | Oberbau | 857.7 | 857.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,858.300 | Gleis | 0,858.300 | Schwelle | Oberbau | 858.3 | 858.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,858.900 | Gleis | 0,858.900 | Schwelle | Oberbau | 858.9 | 858.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,859.500 | Gleis | 0,859.500 | Schwelle | Oberbau | 859.5 | 859.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,860.100 | Gleis | 0,860.100 | Schwelle | Oberbau | 860.1 | 860.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,860.700 | Gleis | 0,860.700 | Schwelle | Oberbau | 860.7 | 860.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,861.300 | Gleis | 0,861.300 | Schwelle | Oberbau | 861.3 | 861.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,861.900 | Gleis | 0,861.900 | Schwelle | Oberbau | 861.9 | 861.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,862.500 | Gleis | 0,862.500 | Schwelle | Oberbau | 862.5 | 862.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,863.100 | Gleis | 0,863.100 | Schwelle | Oberbau | 863.1 | 863.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,863.700 | Gleis | 0,863.700 | Schwelle | Oberbau | 863.7 | 863.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,864.300 | Gleis | 0,864.300 | Schwelle | Oberbau | 864.3 | 864.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,864.900 | Gleis | 0,864.900 | Schwelle | Oberbau | 864.9 | 864.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,865.500 | Gleis | 0,865.500 | Schwelle | Oberbau | 865.5 | 865.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,866.100 | Gleis | 0,866.100 | Schwelle | Oberbau | 866.1 | 866.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,866.700 | Gleis | 0,866.700 | Schwelle | Oberbau | 866.7 | 866.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,867.300 | Gleis | 0,867.300 | Schwelle | Oberbau | 867.3 | 867.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,867.900 | Gleis | 0,867.900 | Schwelle | Oberbau | 867.9 | 867.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,868.500 | Gleis | 0,868.500 | Schwelle | Oberbau | 868.5 | 868.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,869.100 | Gleis | 0,869.100 | Schwelle | Oberbau | 869.1 | 869.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,869.700 | Gleis | 0,869.700 | Schwelle | Oberbau | 869.7 | 869.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,870.300 | Gleis | 0,870.300 | Schwelle | Oberbau | 870.3 | 870.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,870.900 | Gleis | 0,870.900 | Schwelle | Oberbau | 870.9 | 870.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,871.500 | Gleis | 0,871.500 | Schwelle | Oberbau | 871.5 | 871.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,872.100 | Gleis | 0,872.100 | Schwelle | Oberbau | 872.1 | 872.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,872.700 | Gleis | 0,872.700 | Schwelle | Oberbau | 872.7 | 872.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,873.300 | Gleis | 0,873.300 | Schwelle | Oberbau | 873.3 | 873.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,873.900 | Gleis | 0,873.900 | Schwelle | Oberbau | 873.9 | 873.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,874.500 | Gleis | 0,874.500 | Schwelle | Oberbau | 874.5 | 874.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,875.100 | Gleis | 0,875.100 | Schwelle | Oberbau | 875.1 | 875.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,875.700 | Gleis | 0,875.700 | Schwelle | Oberbau | 875.7 | 875.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,876.300 | Gleis | 0,876.300 | Schwelle | Oberbau | 876.3 | 876.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,876.900 | Gleis | 0,876.900 | Schwelle | Oberbau | 876.9 | 876.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,877.500 | Gleis | 0,877.500 | Schwelle | Oberbau | 877.5 | 877.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,878.100 | Gleis | 0,878.100 | Schwelle | Oberbau | 878.1 | 878.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,878.700 | Gleis | 0,878.700 | Schwelle | Oberbau | 878.7 | 878.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,879.300 | Gleis | 0,879.300 | Schwelle | Oberbau | 879.3 | 879.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,879.900 | Gleis | 0,879.900 | Schwelle | Oberbau | 879.9 | 879.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,880.500 | Gleis | 0,880.500 | Schwelle | Oberbau | 880.5 | 880.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,881.100 | Gleis | 0,881.100 | Schwelle | Oberbau | 881.1 | 881.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,881.700 | Gleis | 0,881.700 | Schwelle | Oberbau | 881.7 | 881.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,882.300 | Gleis | 0,882.300 | Schwelle | Oberbau | 882.3 | 882.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,882.900 | Gleis | 0,882.900 | Schwelle | Oberbau | 882.9 | 882.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,883.500 | Gleis | 0,883.500 | Schwelle | Oberbau | 883.5 | 883.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,884.100 | Gleis | 0,884.100 | Schwelle | Oberbau | 884.1 | 884.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,884.700 | Gleis | 0,884.700 | Schwelle | Oberbau | 884.7 | 884.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,885.300 | Gleis | 0,885.300 | Schwelle | Oberbau | 885.3 | 885.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,885.900 | Gleis | 0,885.900 | Schwelle | Oberbau | 885.9 | 885.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,886.500 | Gleis | 0,886.500 | Schwelle | Oberbau | 886.5 | 886.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,887.100 | Gleis | 0,887.100 | Schwelle | Oberbau | 887.1 | 887.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,887.700 | Gleis | 0,887.700 | Schwelle | Oberbau | 887.7 | 887.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,888.300 | Gleis | 0,888.300 | Schwelle | Oberbau | 888.3 | 888.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,888.900 | Gleis | 0,888.900 | Schwelle | Oberbau | 888.9 | 888.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,889.500 | Gleis | 0,889.500 | Schwelle | Oberbau | 889.5 | 889.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,890.100 | Gleis | 0,890.100 | Schwelle | Oberbau | 890.1 | 890.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,890.700 | Gleis | 0,890.700 | Schwelle | Oberbau | 890.7 | 890.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,891.300 | Gleis | 0,891.300 | Schwelle | Oberbau | 891.3 | 891.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,891.900 | Gleis | 0,891.900 | Schwelle | Oberbau | 891.9 | 891.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,892.500 | Gleis | 0,892.500 | Schwelle | Oberbau | 892.5 | 892.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,893.100 | Gleis | 0,893.100 | Schwelle | Oberbau | 893.1 | 893.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,893.700 | Gleis | 0,893.700 | Schwelle | Oberbau | 893.7 | 893.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,894.300 | Gleis | 0,894.300 | Schwelle | Oberbau | 894.3 | 894.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,894.900 | Gleis | 0,894.900 | Schwelle | Oberbau | 894.9 | 894.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,895.500 | Gleis | 0,895.500 | Schwelle | Oberbau | 895.5 | 895.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,896.100 | Gleis | 0,896.100 | Schwelle | Oberbau | 896.1 | 896.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,896.700 | Gleis | 0,896.700 | Schwelle | Oberbau | 896.7 | 896.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,897.300 | Gleis | 0,897.300 | Schwelle | Oberbau | 897.3 | 897.3 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,897.900 | Gleis | 0,897.900 | Schwelle | Oberbau | 897.9 | 897.9 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,898.500 | Gleis | 0,898.500 | Schwelle | Oberbau | 898.5 | 898.5 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,899.100 | Gleis | 0,899.100 | Schwelle | Oberbau | 899.1 | 899.1 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
Schwelle | Schwelle | 0,899.700 | Gleis | 0,899.700 | Schwelle | Oberbau | 899.7 | 899.7 | Schwelle | 0.21 | B70 (2.6, 0.21) | Gleis 1 | 0.3 | 2.6
